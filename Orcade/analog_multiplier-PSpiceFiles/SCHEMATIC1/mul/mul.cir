** Profile: "SCHEMATIC1-mul"  [ D:\SIMRAN_GUPTA_INTERN\Orcade\analog_multiplier-pspicefiles\schematic1\mul.sim ]

** Creating circuit file "mul.cir"
** WARNING: THIS AUTOMATICALLY GENERATED FILE MAY BE OVERWRITTEN BY SUBSEQUENT SIMULATIONS

*Libraries:
* Profile Libraries :
* Local Libraries :
* From [PSPICE NETLIST] section of C:\SPB_Data\cdssetup\OrCAD_PSpice/16.6.0/PSpice.ini file:
.lib "C:\Cadence\SPB_16.6\tools\capture\library\awbmc33172..lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\MC33172.lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\MC33172..lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\AD8030..lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPAM2GD.lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPAM1DS.lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\MOSFET\NMOS.lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\MOSFET\PMOS.lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPA_W7inc.lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPA_W7dec.lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPA_W5inc.lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPA_W5dec.lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPA_L7inc.lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPA_L7dec.lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPA_L5inc.lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPA_L5dec.lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPAM7Do.lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPAM5DS.lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPA_R5k.lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPA_Rdec.lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPA_Rinc.lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPA.lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPAM1GD.lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPAM2DS.lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPAM4GD.lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPAM1GS.lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPA_CC.lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPA_L6.lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPA_W6.lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPA_CcDecre..lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPA_CcDecr..lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPA_W6dec..lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPA_CcDec..lib"
.lib "C:\Cadence\SPB_16.6\tools\capture\library\OPA_L6dec..lib"
.lib "nom.lib"

*Analysis directives:
.TRAN  0 10ms 0 50u
.OPTIONS ADVCONV
.PROBE64 V(alias(*)) I(alias(*)) W(alias(*)) D(alias(*)) NOISE(alias(*))
.INC "..\SCHEMATIC1.net"

.END
